# Keil uVision project simple_test.uvproj, settings and files
target simple_test (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0-0x7FFFF) CLOCK(84000000) CPUTYPE("Cortex-M4") FPU2
  output: simple_test +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3
  c define: RVDS_ARMCM4_NUC4xx
  c misc: --diag_suppress=550,177,C4017,111
  c include: ..\;..\..\..\..\..\M480BSP\ThirdParty\FreeRTOS\Source\include;..\..\..\..\..\M480BSP\Library\Device\Nuvoton\M480\Include;..\..\..\..\..\M480BSP\Library\StdDriver\inc;..\..\..\..\..\M480BSP\ThirdParty\FreeRTOS\DEMO\COMMON\include;..\..\..\..\..\M480BSP\ThirdParty\FreeRTOS\SOURCE\portable\RVDS\ARM_CM4F;..\..\..\..\..\M480BSP\ThirdParty\lwip\src\include;..\..\..\..\..\M480BSP\SampleCode\FreeRTOS_lwIP\lwIP\include;..\..\..\..\..\M480BSP\Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group CMSIS
    ../../../../../M480BSP/Library/Device/Nuvoton/M480/Source/: system_M480.c
    ../../../../../M480BSP/Library/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
  group User
    ../: main.c FreeRTOSConfig.h simple_test.c
  group FreeRTOS
    ../../../../../M480BSP/ThirdParty/FreeRTOS/Source/: list.c tasks.c timers.c queue.c
    ../../../../../M480BSP/ThirdParty/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../M480BSP/ThirdParty/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Library
    ../../../../../M480BSP/Library/StdDriver/src/: clk.c retarget.c sys.c uart.c
  group LwIP
    ../../../../../M480BSP/ThirdParty/lwip/src/core/: def.c
  group SOEM
    ../../../../oshw/numicro_m487/nu_emac/: nu_emac.c
    ../../../../oshw/numicro_m487/: nicdrv.c oshw.c
    ../../../../osal/freertos/: osal.c
    ../../../../soem/: ethercatbase.c ethercatcoe.c ethercatconfig.c ethercatdc.c ethercatfoe.c ethercatmain.c ethercatprint.c ethercatsoe.c
